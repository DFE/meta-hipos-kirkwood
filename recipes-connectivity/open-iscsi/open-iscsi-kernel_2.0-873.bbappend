
PR_append = "+r0"
COMPATIBLE_MACHINE_hidav-kirkwood = "hidav-kirkwood"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_hidav-kirkwood = " file://static-kernel-version.patch "

